<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\..\..\..\..\..\..\..\..\Documents\IAR\Prj\0514\0514_1.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\kl16z128_eslora.ewp</path>
    </project>
    <batchBuild />
</workspace>
