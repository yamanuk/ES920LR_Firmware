# IAR project kl16z128_eslora のバックアップ.ewp, settings and files
configuration kl16z128_eslora MQXLite (ARM, debug)
  General.OGChipSelectEditMenu: MKL16Z128xxx4 Freescale MKL16Z128xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCIncludePath2: Interface; Sources; ..\MQXLITE\include; ..\MQXLITE\config; ..\MQXLITE\psp\cortex_m; ..\MQXLITE\psp\cortex_m\compiler\iar; ..\drv\Generated_Code; ..\drv\PExSupport\Kinetis; ..\framework\OSAbstraction\MQXLite\Interface; ..\framework\RNG\Interface; ..\framework\Common; ..\framework\Utils\Lists; ..\framework\Utils\FunctionLib; ..\framework\Utils\SecLib; ..\framework\FSCI\Interface; ..\framework\FSCI\Source; ..\framework\Panic\Interface; ..\framework\SerialManager\Interface; ..\framework\MemManager\Interface; ..\framework\TimersManager\Interface; ..\framework\TimersManager\Source; ..\framework\Messaging\Interface; ..\framework\RNG\Interface; ..\framework\RNG\Source; ..\ieee_802_15_4\Phy\Interface; ..\ieee_802_15_4\SMAC\Interface; ..\drv\Portable\ADC\Interface; ..\drv\Portable\BME\Interface; ..\drv\Portable\Flash\Interface; ..\drv\Portable\I2C\Interface; ..\drv\Portable\LED\Interface; ..\drv\Portable\LLWU\Interface; ..\drv\Portable\LPTMR\Interface; ..\drv\Portable\SMC\Interface; ..\drv\Portable\MCG\Interface; ..\drv\Portable\Reset
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\MQXLITE\psp\cortex_m\compiler\iar; ..\MQXLITE\psp\cortex_m; ..\MQXLITE\include; ..\MQXLITE\config; ..\drv\Generated_Code
  OBJCOPY.OOCOutputFile: kl16z128_eslora.srec
  ILINK.IlinkOutputFile: kl16z128_eslora.out
  ILINK.IlinkIcfFile: MKL16_Custom_Linker_File.icf
  ILINK.IlinkAdditionalLibs: $TOOLKIT_DIR$\lib\rt6M_tl.a; $TOOLKIT_DIR$\lib\shb_l.a; $TOOLKIT_DIR$\lib\m6M_tl.a; $TOOLKIT_DIR$\lib\dl6M_tln.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group drv/ADC/Interface
    ../drv/Portable/ADC/Interface/: adc16.h
  group drv/ADC/Source
    ../drv/Portable/ADC/Source/: adc16.c
  group drv/BME/Interface
    ../drv/Portable/BME/Interface/: BME.h
  group drv/Flash/Interface
    ../drv/Portable/Flash/Interface/: flash.h
  group drv/Flash/Source
    ../drv/Portable/Flash/Source/: flash.c flash_RamFunc.c
  group drv/I2C/Interface
    ../drv/Portable/I2C/Interface/: i2c.h
  group drv/I2C/Source
    ../drv/Portable/I2C/Source/: i2c.c
  group drv/LED/Interface
    ../drv/Portable/LED/Interface/: LED.h LED_Config.h
  group drv/LED/Source
    ../drv/Portable/LED/Source/: LED.c
  group drv/LLWU/Interface
    ../drv/Portable/LLWU/Interface/: llwu.h
  group drv/LLWU/Source
    ../drv/Portable/LLWU/Source/: llwu.c
  group drv/LPTMR/Interface
    ../drv/Portable/LPTMR/Interface/: lptmr.h
  group drv/LPTMR/Source
    ../drv/Portable/LPTMR/Source/: lptmr.c
  group drv/MCG/Interface
    ../drv/Portable/MCG/Interface/: mcg.h
  group drv/MCG/Source
    ../drv/Portable/MCG/Source/: mcg.c
  group drv/Reset
    ../drv/Portable/Reset/: Reset.c
  group drv/SMC/Interface
    ../drv/Portable/SMC/Interface/: smc.h
  group drv/SMC/Source
    ../drv/Portable/SMC/Source/: smc.c
  group framework/Common
    ../framework/Common/: EmbeddedTypes.h
  group framework/MemManager/Interface
    ../framework/MemManager/Interface/: MemManager.h MemManagerConfig.h
  group framework/MemManager/Source
    ../framework/MemManager/Source/: MemManager.c
  group framework/Messaging/Interface
    ../framework/Messaging/Interface/: Messaging.h
  group framework/Messaging/Source
    ../framework/Messaging/Source/: Messaging.c
  group framework/OSAbstraction/MQXLite/Interface
    ../framework/OSAbstraction/MQXLite/Interface/: cmsis_os.h OSAbstractionConfig.h
  group framework/OSAbstraction/MQXLite/Source
    ../framework/OSAbstraction/MQXLite/Source/: MQXLite_Adapter.c
  group framework/Panic/Interface
    ../framework/Panic/Interface/: Panic.h PanicConfig.h
  group framework/Panic/Source
    ../framework/Panic/Source/: Panic.c
  group framework/RNG/Interface
    ../framework/RNG/Interface/: RNG_Interface.h
  group framework/RNG/Source
    ../framework/RNG/Source/: RNG.c
  group framework/SerialManager/Interface
    ../framework/SerialManager/Interface/: SerialManager.h SerialManagerConfig.h
  group framework/SerialManager/Source
    ../framework/SerialManager/Source/: SerialManager.c
  group framework/TimersManager/Interface
    ../framework/TimersManager/Interface/: TimersManager.h TimersManagerConfig.h TimersManagerInternal.h
  group framework/TimersManager/Source
    ../framework/TimersManager/Source/: TimersManager.c
  group framework/Utils/FunctionLib
    ../framework/Utils/FunctionLib/: FunctionLib.c FunctionLib.h
  group framework/Utils/Lists
    ../framework/Utils/Lists/: GenericList.c GenericList.h
  group framework/Utils/SecLib
    ../framework/Utils/SecLib/: mmcau_interface.h
  group Generated_Code
    ../drv/Generated_Code/: Cpu.c Cpu.h DataAvailablePin.c DataAvailablePin.h I2CDriver.c I2CDriver.h IO_Map.h LED1.c LED1.h LED2.c LED2.h MQXLite1.c MQXLite1.h PE_Const.h PE_Error.h PE_LDD.c PE_LDD.h PE_Types.h PitTimeStamp.c PitTimeStamp.h RealTimeClock.c RealTimeClock.h SPISlave.c SPISlave.h StackTimer.c StackTimer.h SystemTimer1.c SystemTimer1.h UARTA.c UARTA.h UARTB.c UARTB.h Vectors.c
  group Interface
    Interface/: Application_Interface.h
  group MQXLITE/config
    ../MQXLITE/config/: task_template_list.c task_template_list.h user_config.h
  group MQXLITE/include
    ../MQXLITE/include/: klog.h log.h lwevent.h lwevent_prv.h lwlog.h lwlog_prv.h lwmsgq.h lwmsgq_prv.h lwsem.h lwsem_prv.h lwtimer.h lwtimer_prv.h mqx_cnfg.h mqx_cpudef.h mqx_inc.h mqx_macros.h mqx_str.h mqxlite.h mqxlite_cnfg.h mqxlite_prv.h mutex.h mutex_prv.h queue.h
  group MQXLITE/kernel
    ../MQXLITE/kernel/: idletask.c int.c klog.c lwevent.c lwlog.c lwmsgq.c lwsem.c lwtimer.c mqx_utils.c mqxlite.c mutex.c qu_test.c sched.c task.c time_ticks.c
  group MQXLITE/psp/cortex_m
    ../MQXLITE/psp/cortex_m/: cortex.c cortex.h int_gkis.c int_inst.c int_kisr.c int_pvta.c int_unx.c int_vtab.c int_xcpt.c kinetis.h mem_zero.c psp_comp.h psp_cpu.h psp_cpudef.h psp_iinit.c psp_prv.h psp_supp.c psp_supp.h psp_tiad.c psp_ticks.h psp_tinm.c psp_tisu.c psplite.h psptypes.h sc_irdyq.c stack_bu.c stack_de.c stack_st.c types.inc
  group MQXLITE/psp/cortex_m/compiler/iar
    ../MQXLITE/psp/cortex_m/compiler/iar/: asm_mac.h comp.h
  group MQXLITE/psp/cortex_m/core/M0
    ../MQXLITE/psp/cortex_m/core/M0/: boot.S dispatch.S psp_prv.inc
  group PHY/Interface
    ../ieee_802_15_4/Phy/Interface/: radio.h sx1276-Fsk.h sx1276-FskMisc.h sx1276-Hal.h sx1276-LoRa.h sx1276-LoRaMisc.h sx1276-Spi.h sx1276.h
  group PHY/Sources
    ../ieee_802_15_4/Phy/Source/: radio.c sx1276-Fsk.c sx1276-FskMisc.c sx1276-Hal.c sx1276-LoRa.c sx1276-LoRaMisc.c sx1276-Spi.c sx1276.c
  group SMAC/Interface
    ../ieee_802_15_4/SMAC/Interface/: cca.h smac.h
  group SMAC/Sources
    ../ieee_802_15_4/SMAC/Source/: cca.c smac.c
  group Sources
    Sources/: Events.c Events.h menus.c menus.h message.c message.h mqx_tasks.c mqx_tasks.h ProcessorExpert.c usr_tasks.c usr_tasks.h
